# Keil uVision project STM32L1xx_Demo.uvprojx, settings and files
target STM32L1XX_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1xx_demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\CORE;..\STM32L1xx_FWLib\src;..\STM32L1xx_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\common;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM3;..\User;..\Deriver\LED;..\Application\App;..\Application\LEDTASK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application
    ../Application/App/: app.c
    ../Application/LEDTASK/: ledtask.c
  group Driver
    ../Deriver/LED/: led.c
  group Common
    ../SYSTEM/common/: common.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group User
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c MainConfig.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group Core
    ../CORE/: core_cm3.c startup_stm32l1xx_md.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/MemMang/: heap_4.c
  group FWLib
    ../STM32L1xx_FWLib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Document
    ../: readme.md
software components: Data Exchange:JSON:Jansson 2.7.0
